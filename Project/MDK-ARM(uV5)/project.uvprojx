# Keil uVision project project.uvprojx, settings and files
target Flash（0x08020000） (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_h7_tool.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,USE_USB_HS,STM32H7,NO_HOST
  c misc: --locale=english
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\fonts;..\..\User\images;..\..\User\app\inc;..\..\Libraries\FatFs\src;..\..\Libraries\FatFs\src\drivers;..\..\Libraries\LwIP\src\include;..\..\Libraries\LwIP\src\apps;..\..\Libraries\LwIP\system;..\..\Libraries\LwIP\phy_drv;..\..\User\lwip_if;..\..\User\lwip_http;..\..\User\lwip_tcp;..\..\Libraries\STM32_USB_Device_Library\Core\Inc;..\..\Libraries\STM32_USB_Device_Library\Class\MSC\Inc;..\..\User\modbus;..\..\User\programmer;..\..\User\lua\src;..\..\User\lua\if;..\..\User\st_usb;..\..\User\st_usb\usbd_virtual_com;..\..\User\st_usb\usbd_mass_storage;..\..\Libraries\STM32_USB_Device_Library\Class\CDC\Inc;..\..\User\daplink\source\daplink\cmsis-dap;..\..\User\daplink\source\target;..\..\User\daplink\source\family\st\stm32h7;..\..\User\daplink\source\hic_hal;..\..\User\daplink\source\daplink;..\..\User\daplink\source\hic_hal\stm32\stm32h750;..\..\User\daplink\source\rtos_none;..\..\User\daplink\source\daplink\interface;..\..\User\daplink\source\daplink\settings;..\..\User\daplink\source\usb;..\..\User\teeny_usb\usb_stack\inc;..\..\User\teeny_usb\usb_stack\class;..\..\User\teeny_usb\usb_app;..\..\User\daplink\source\target;..\..\User\encrypt_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\h7-tool_debug.sct
  group App
    ../../User/app/inc/: includes.h ui_def.h param.h
    ../../User/app/src/: main.c param.c lcd_menu.c status_system_set.c status_resistor_meter.c status_current_meter.c status_temp_meter.c status_voltage_meter.c status_programmer.c status_link_mode.c status_tvcc_power.c status_pluse_meter.c status_extend_menu.c status_lua.c wifi_if.c status_usb_uart.c status_mini_dso.c modify_param.c status_can_monitor.c status_uart_monitor.c status_ds18b20_meter.c status_esp32.c status_file_mange.c status_hard_info.c status_usb_emmc.c disp_lib.c file_lib.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h nvic_prio_cfg.h bsp_msg.h bsp_msg.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_timer.c bsp_user_lib.c bsp_led.c bsp_tim_pwm.c bsp_i2c_eeprom_24xx.c bsp_i2c_gpio.c bsp_tft_lcd.c bsp_key.c bsp_beep.c bsp_spi_bus.c bsp_cpu_adc.c bsp_cpu_dac.c bsp_can.c bsp_tft_st7789.c bsp_i2c_mcp4018.c bsp_power_tvcc.c bsp_fmc_io.c bsp_uart_fifo.c bsp_period_ctrl.c bsp_tim_dma.c bsp_tim_capture.c bsp_cpu_flash.c bsp_esp32_at.c bsp_i2c_mcp4725.c bsp_qspi_w25q256.c bsp_cpu_rtc.c bsp_74hc595_io.c bsp_emmc.c bsp_spi_fast.c bsp_ntc.c bsp_ext_io.c bsp_rng.c bsp_i2c_gpio_ext.c bsp_ds18b20.c
  group MDK-ARM
    ./: startup_stm32h743xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_sdmmc.c stm32h7xx_hal_fdcan.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc.c stm32h7xx_hal_spi.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_hcd.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_pcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_nand.c stm32h7xx_hal_sai.c stm32h7xx_hal_eth.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_lptim.c stm32h7xx_hal_nor.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mmc.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rng.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group CMSIS
    ../../User/bsp/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Doc
    ../../: CHANGELOG
    ../../Doc/: 待解决问题.txt
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c asc62x40.c asc96x40.c
  group Images
    ../../User/images/: ADC.c Camera.c ChiLun.c chujiao.c FM.c GPS.c hwinfo.c images.h LCD.c MP3.c Phone.c radio.c Recorder.c USBDisk.c web.c Wireless.c
  group FatFS
    ../../Libraries/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../Libraries/FatFs/src/option/: syscall.c cc936.c
    ../../Libraries/FatFs/src/drivers/: emmc_diskio_dma.c
  group LwIP
    ../../Libraries/LwIP/src/netif/: ethernet.c
    ../../Libraries/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../Libraries/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Libraries/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP_PhyDrv
    ../../Libraries/LwIP/phy_drv/: lan8742.c
  group LwIP_IF
    ../../User/lwip_if/: app_ethernet.c ethernetif.c lwipopts.h lwip_user.c net_udp.c
  group LwIP_HTTP
    ../../User/lwip_http/: fs.c fsdata_custom.c http_cgi_ssi.h http_client.c httpd.c httpd_cgi_ssi.c
  group LwIP_TCP
    ../../User/lwip_tcp/: tcp_echoclient.c tcp_echoserver.c
  group Modbus
    ../../User/modbus/: modbus_slave.c modbus_register.c modbus_reg_addr.h modbus_file.c modbus_swd.c modbus_print.c modbus_host.c modbus_msg.c
  group Programmer
    ../../User/programmer/: elf_file.c prog_if.c falsh_error.c SWD_flash.c flash_blob.h FlashOS.h SWD_flash.h stm8_swim.c stm8_flash.c edc_crc_a.asm swd_prog_file.c stm8_prog_file.c n76e003_flash.c w25q_flash.c cx32_isp.c pg_prog_file.c
  group Lua src 5.3.5
    ../../User/lua/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group Lua_IF
    ../../User/lua/if/: lua_if_swd.c lua_if.h lua_if.c lua_if_gpio.c lua_if_i2c.c lua_if_spi.c lua_if_tcp_udp.c lua_if_tim.c lua_if_qspi.c lua_if_fatfs.c lua_if_adc.c lua_if_dac.c lua_if_register.c lua_if_extio.c lua_if_uart.c lua_if_uart.h lua_if_swim.c lua_if_disp.c
  group DAP_bsp
    ../../User/daplink/source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c SW_DP_Multi.c DAP.h
    ../../User/daplink/source/hic_hal/stm32/stm32h750/: DAP_config.h
  group DAP_Host
    ../../User/daplink/source/daplink/interface/: swd_host.c swd_host_ca.c swd_host_multi.c
    ../../User/daplink/source/target/: target_family.c
    ../../User/daplink/source/rtos_none/: cmsis_os2_port.c SysTick_Handler.c
  group ST_USB_Device_Library_Core
    ../../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group ST_USB_Device_Library_Class
    ../../Libraries/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Libraries/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group ST_USBD_Virtual_COM
    ../../User/st_usb/: usb_if.h usb_if.c
    ../../User/st_usb/usbd_virtual_com/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c usbd_it.c usbd_conf.h
  group ST_USBD_Mass Storage
    ../../User/st_usb/usbd_mass_storage/: usbd_mass_desc.c usbd_storage.c
  group teeny_usb_app
    ../../User/teeny_usb/usb_app/: board_config.h composite_desc.lua composite_device.c teeny_usb_desc.c teeny_usb_init.h usb_if.h usb_if.c
  group teeny_usb_device
    ../../User/teeny_usb/usb_stack/class/: tusbd.c tusbd_cdc.c tusbd_hid.c tusbd_msc.c tusbd_user.c tusbd_user.h
  group teeny_usb_stack
    ../../User/bsp/: nvic_prio_cfg.h
    ../../User/teeny_usb/usb_stack/src/: stm32_otg_init.c teeny_usb.c teeny_usb_stm32_fs_device.c teeny_usb_stm32_otg_device.c
  group Encrypt
    ../../User/encrypt_lib/: md5.c crc32_stm32.c
